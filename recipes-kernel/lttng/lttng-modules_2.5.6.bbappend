SRC_URI_append_zc702-zynq7-mel = " file://Fix_lttng_this_cpu_ptr_wrapper_for_kernel_3_19_plus.patch \
                                   file://Fix_introduce_lttng_get_unused_fd_wrapper_for_3_19_kernels.patch \
                                   file://Fix_Add_f_dentry_wrapper_for_3_19_plus_kernels.patch \
                                   file://Fix_update_sched_instrumentation_for_3_19_plus_kernels.patch \
                                   file://Fix_update_module_instrumentation_for_3_19_plus_kernels.patch \
                                 "
